<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app\build\iar_stm32f105rbt6\App.ewp</path>
  </project>
  <batchBuild/>
</workspace>



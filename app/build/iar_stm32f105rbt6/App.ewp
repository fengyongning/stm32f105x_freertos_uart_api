# IAR project App.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xB ST STM32F105xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\custom\inc; ..\..\custom\config; ..\..\driver\bsp\stm32f105x_mnc; ..\..\driver\cmsis\include; ..\..\driver\stm32f1xx_hal_driver\inc; ..\..\driver\stm32f1xx_hal_driver\inc\Legacy; ..\..\freertos\source\include; ..\..\freertos\source\cmsis; ..\..\freertos\source\portable\IAR\ARM_CM3; ..\..\hal\inc; ..\..\driver\cmsis\device\st\stm32f1xx\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\custom\config; ..\..\custom\inc; ..\..\driver\stm32f1xx_hal_driver\inc; ..\..\driver\stm32f1xx_hal_driver\inc\Legacy; ..\..\driver\cmsis\include; ..\..\driver\cmsis\device\st\stm32f1xx\inc; ..\..\driver\bsp\stm32f105x_mnc; ..\..\freertos\source\include; ..\..\freertos\source\cmsis; ..\..\freertos\source\portable\IAR\ARM_CM3; ..\..\hal\inc
  OBJCOPY.OOCOutputFile: App.bin
  ILINK.IlinkOutputFile: App.out
  ILINK.IlinkIcfFile: ..\..\driver\cmsis\device\st\stm32f1xx\src\iar\linker\stm32f105xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Custom
    ../../custom/: debug_cmd.c main.c
  group Driver/bsp
    ../../driver/bsp/stm32f105x_mnc/: stm32f105x_mnc.c
  group Driver/cmsis
    ../../driver/cmsis/device/st/stm32f1xx/src/iar/: startup_stm32f105xc.s
    ../../driver/cmsis/device/st/stm32f1xx/src/: stm32f1xx_it.c system_stm32f1xx.c
  group Driver/hal_driver
    ../../driver/stm32f1xx_hal_driver/src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
  group FreeRTOS/port
    ../../freertos/source/cmsis/: cmsis_os.c
    ../../freertos/source/portable/MemMang/: heap_4.c
    ../../freertos/source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FreeRTOS/source
    ../../freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Hal
    ../../hal/: os_inteface.c ph_common.c ph_uart.c

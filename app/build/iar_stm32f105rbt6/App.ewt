<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Custom</name>
    <file>
      <name>$PROJ_DIR$\..\..\custom\Ble.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\custom\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\custom\modem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\custom\obd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\custom\test.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\custom\update.c</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <group>
      <name>bsp</name>
      <file>
        <name>$PROJ_DIR$\..\..\driver\bsp\stm32f105x_mnc\stm32f105x_mnc.c</name>
      </file>
    </group>
    <group>
      <name>cmsis</name>
      <file>
        <name>$PROJ_DIR$\..\..\driver\cmsis\device\st\stm32f1xx\src\iar\startup_stm32f105xc.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\cmsis\device\st\stm32f1xx\src\stm32f1xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\cmsis\device\st\stm32f1xx\src\system_stm32f1xx.c</name>
      </file>
    </group>
    <group>
      <name>hal_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_adc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_dac_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_eth.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_gpio_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_hcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_i2s.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_irda.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_nand.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_nor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_pccard.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_pcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_pcd_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_rtc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_sd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_smartcard.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_spi_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_sram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_hal_wwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_ll_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_ll_sdmmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\driver\stm32f1xx_hal_driver\src\stm32f1xx_ll_usb.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>FreeRTOS</name>
    <group>
      <name>port</name>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\cmsis\cmsis_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\portable\MemMang\heap_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\portable\IAR\ARM_CM3\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\portable\IAR\ARM_CM3\portasm.s</name>
      </file>
    </group>
    <group>
      <name>source</name>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\croutine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\event_groups.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\freertos\source\timers.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Hal</name>
    <file>
      <name>$PROJ_DIR$\..\..\hal\debug_cmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\flash_ext.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\formula.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\os_inteface.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\ph_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\ph_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\ph_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\ph_uart.c</name>
    </file>
  </group>
</project>


